# Keil uVision project 26_competuer.uvprojx, settings and files
target Target_1 (6180000::V6.18::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.5.8.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: 26_competuer +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  c include: .\code
  asm misc: --via=via/rasc_armasm.via
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group code
    ./code/: AS608pro.c AS608pro.h fun.c fun.h headfile.h pn532.c pn532.h PN532_def.h PN532_hal.c tjc_usart_hmi.c tjc_usart_hmi.h k230_connect.c k230_connect.h esp_connect.c esp_connect.h asr_pro.c asr_pro.h motor.c motor.h
software components: Flex Software:RA Configuration 1.0.0
